## extdrv/tp/gt9xx/Kconfig
```kconfig
#
# Touchscreen driver configuration
#

config TOUCHSCREEN_GT9XX
	tristate "betterlife tp"
	---help-- -
	betterlife fingerprint.
```
