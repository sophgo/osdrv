## extdrv/tp/ts_gt9xx/Kconfig
```kconfig
#
# Touchscreen driver configuration
#

config TOUCHSCREEN_GT9XX
	tristate "GT9XX tp"
	default m
	---help-- -
	GT9XX for cardv.
```
